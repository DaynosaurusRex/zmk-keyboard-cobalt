## boards/shields/cobalt/Kconfig.shield
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_COBALT
    def_bool $(shields_list_contains,cobalt)
```
